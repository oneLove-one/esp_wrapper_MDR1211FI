# Keil uVision project esp_wrapper.uvprojx, settings and files
target main (6240000::V6.24::ARMCLANG)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: esp_wrapper
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ./source/: c_systemclock.cpp c_timer.cpp c_gpio.cpp c_peripheralregistry.cpp
  group include
    ./include/: types.hpp c_peripheralregistry.hpp c_pindefinitions.hpp c_gpio.hpp c_timer.hpp c_systemclock.hpp
  group core
    ./: main.cpp
    ./core/: c_core.cpp c_core.hpp
software components: Device:Startup 2.2.0i, Drivers:I2C 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i
